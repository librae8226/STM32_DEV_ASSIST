# Keil uVision project Project.uvproj, settings and files
target STM32_DQ_128K_64P (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_DQ_128K_64P +hex
  c flags: Optim=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM32_DQ_128K_64P
  c include: ..\;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\App;..\..\App\DataStrcuture;..\..\Driver;..\..\OS;..\..\OS\port;..\..\FATFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group App
    ../../App/: main.c stm32f10x_it.c c_lib_retarget.c task_manage.c general_task.c servo.c gps.c Serial_Shell.c
  group DataStructure
    ../../App/DataStrcuture/: DataStructure.c
  group Driver
    ../../Driver/: CPU_Init.c LTM022A69B.c LCD_lib.c SD_Driver.c ffext.c NRF24L01.c OV7725.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group uC/OS-II_Port
    ../../OS/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-II_Source
    ../../OS/: uCOS_II.H OS_CORE.C OS_TASK.C OS_Q.C OS_SEM.C OS_TIME.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C
  group FATFS
    ../../FATFS/src/: ff.c diskio.c
  group Doc
    ../../Documentation/: release_notes.txt readme.txt note.txt pin_connection
target STM32_CORE_512K_100P (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_CORE_512K_100P +hex
  c flags: Optim=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM32_CORE_512K_100P
  c include: ..\;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\App;..\..\Driver;..\..\OS;..\..\OS\port;..\..\FATFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
